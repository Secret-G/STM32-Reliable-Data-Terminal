# Keil uVision project Boot_Loader.uvprojx, settings and files
target f4-test-add-uart (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: f4-test +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: fromelf--bin--output./f4-test/Objects/f4-test.bin./f4-test/Objects/f4-test.axf;../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP;../Drivers/BSP/KEY;../Drivers/BSP/boot_confirm;..\..\Common\FirmwareUpdate\boot_cache;..\..\Common\FirmwareUpdate\boot_crc;..\..\Common\FirmwareUpdate\boot_flag;..\..\Common\FirmwareUpdate\boot_flash;..\..\Common\FirmwareUpdate\boot_protocol
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/BSP
    ../Drivers/BSP/: int_bootloader.c
    ../Drivers/BSP/KEY/: key.c
    ../Drivers/BSP/boot_confirm/: boot_confirm.c
    ../../Common/FirmwareUpdate/boot_cache/: boot_cache.c
    ../../Common/FirmwareUpdate/boot_crc/: boot_crc.c
    ../../Common/FirmwareUpdate/boot_flag/: boot_flag.c
    ../../Common/FirmwareUpdate/boot_flash/: boot_flash.c
    ../../Common/FirmwareUpdate/boot_protocol/: boot_protocol.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 6.1.1
