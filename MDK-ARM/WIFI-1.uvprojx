# Keil uVision project WIFI-1.uvprojx, settings and files
target WIFI-1 (6240000::V6.24::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: WIFI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP/esp32;../Drivers/BSP/protocol;..\Drivers\BSP\storage;..\Drivers\BSP\data;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\Drivers\BSP\uplink;..\Drivers\BSP\wifi_ota;..\Drivers\BSP\app_update;..\Drivers\BSP\app_trial;..\Drivers\BSP\boot_confirm;..\Common\FirmwareUpdate\boot_cache;..\Common\FirmwareUpdate\boot_crc;..\Common\FirmwareUpdate\boot_flag;..\Common\FirmwareUpdate\boot_flash;..\Common\FirmwareUpdate\boot_protocol
  asm include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c sdio.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group BSP
    ../Drivers/BSP/esp32/: esp32.c
    ../Drivers/BSP/esp32/driver/: esp32_driver.c
    ../Drivers/BSP/esp32/at/: esp32_at_parser.c
    ../Drivers/BSP/esp32/tcp/: esp32_tcp_parser.c
    ../Drivers/BSP/esp32/event/: esp32_event.c
    ../Drivers/BSP/esp32/application/: esp32_network.c
    ../Drivers/BSP/protocol/: device_protocol.c
    ../Drivers/BSP/storage/: storage_service.c
    ../Drivers/BSP/data/: data_producer.c
    ../Drivers/BSP/uplink/: uplink_manager.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c fatfs_platform.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_mmc.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/OTA
    ../Drivers/BSP/wifi_ota/: wifi_ota.c wifi_ota_port.c
    ../Drivers/BSP/app_update/: app_update.c
    ../Drivers/BSP/app_trial/: app_trial.c
    ../Drivers/BSP/boot_confirm/: boot_confirm.c
    ../Common/FirmwareUpdate/boot_cache/: boot_cache.c
    ../Common/FirmwareUpdate/boot_crc/: boot_crc.c
    ../Common/FirmwareUpdate/boot_flag/: boot_flag.c
    ../Common/FirmwareUpdate/boot_flash/: boot_flash.c
    ../Common/FirmwareUpdate/boot_protocol/: boot_protocol.c
software components: CMSIS:CORE 6.1.1
